options:
  parameters:
    author: Tall Paul
    generate_options: qt_gui
    id: am
    output_language: python
    title: AM Transmitter
  states: {}

blocks:
- name: audio_sample_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audiogain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0
    label: Audio Gain
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1:1,1
    label: freq
    start: 929e6
    step: '100'
    stop: 931e6
    value: 930e6
  states: {}
- name: ifgain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1:0,1
    label: IF Gain
    start: '0'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: inputon
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tabs@0:1,0
    label: Enable Audio Input
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: rf_sample_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1:0,0
    label: RF Gain
    start: '0'
    step: '1'
    stop: '30'
    value: '14'
  states: {}
- name: transmit
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: tabs@1:1,0
    label: Enable RF Output
    'true': '1'
    type: real
    value: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '2'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 930e6
    offset: '0'
    phase: '0'
    samp_rate: rf_sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      DC shift up to
      centre at 1
      between 0 and 2
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: |-
      Divide by 2 to
      centred at 0.5
      between 0 and 1
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Input gain
    const: audiogain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: transmit
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: transmit
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Input on/off
    const: inputon
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: |-
      Activate if you don't
      have a HackRF
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Audio source file
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '0'
    comment: Hack RF
    freq0: freq
    gain0: rfgain*transmit
    if_gain0: ifgain*transmit
    sample_rate: 1.92e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_sample_rate
    comment: Dummy spectrum analyser
    fc: freq
    fftsize: '1024'
    gui_hint: tabs@1:2,0,1,2
    name: '"Dummy RF spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@0:2,0
    label1: Carrier
    size: '1024'
    srate: audio_sample_rate
    type: float
    update_time: '0.02'
    width1: '3'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Change sample rate
    decim: int(audio_sample_rate)
    interp: int(rf_sample_rate)
    taps: ''
    type: ccc
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Audio
    label1: RF
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: audiochain
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: audiochain
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_divide_xx_0, '0', virtual_sink_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_null_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_1_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [virtual_source_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
